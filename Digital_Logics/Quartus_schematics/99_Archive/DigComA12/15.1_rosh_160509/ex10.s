	ORG 0
ZRO,	HEX 0		
	BUN ISV	

	ORG 100
	CLA
	OUT
	ION			
LOP,	LDA X
	ADD Y
	STA Z
	BUN LOP

ISV,	STA SAC
	CIR
	STA SE
	SKI
	BUN NXT
	INP
	STA X
NXT,	SKO
	BUN EXT
	LDA Z
	OUT
EXT,	LDA SE
	CIL
	LDA SAC
	ION
	BUN ZRO I

X,	HEX 10
Y,	HEX 20
Z,	HEX 0
SAC,	HEX 0
SE,	HEX 0
	END