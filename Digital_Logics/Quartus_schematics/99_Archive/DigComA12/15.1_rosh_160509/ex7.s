	ORG 100
	BSA MVE
	HEX 120	
	HEX 140	
	DEC -6	
	HLT	
MVE,	HEX 0		
	LDA MVE I	
	STA PT1	
	ISZ MVE	
	LDA MVE I
	STA PT2	
	ISZ MVE	
	LDA MVE I
	STA CTR	
	ISZ MVE	
LOP,	LDA PT1 I	
	STA PT2 I
	ISZ PT1	
	ISZ PT2	
	ISZ CTR	
	BUN LOP	
	BUN MVE I
PT1,
PT2,
CTR,
	ORG 120
	DEC 11
	DEC 22
	DEC 33
	DEC 44
	DEC 55
	DEC 66

	ORG 140
	END
